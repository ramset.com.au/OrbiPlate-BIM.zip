Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2021-01-10T16:48:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Jan 10 16:48:53 2021 * Host: DESKTOP-6FN9L0T * Database: C:\Users\MPC\AppData\Local\Temp\{0E74B7FA-3A09-45E2-AB67-ABF32E3481CA}\ifc * Database version: 5507 * Database creation date: Sun Jan 10 16:48:46 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Jan 10 16:48:47 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Jan 10 16:48:47 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Widgets; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 12/16mm ReidBrace, M_ReidBrace:12/16mm ReidBrace:213613
In: Level 1
Type - Material: S. G. Iron Galvanised
Pset_BuildingElementProxyCommon - Reference: 12/16mm ReidBrace

# IfcBuildingElementProxy: 12mm ReidBar Coupler (2)
In: Level 1
Type - Material: S. G. Iron
Pset_BuildingElementProxyCommon - Reference: 12mm ReidBar Coupler
Name
M_ReidBar Couplers AUS:12mm ReidBar Coupler:209368
M_ReidBar Couplers NZ:12mm ReidBar Coupler:242016

# IfcBuildingElementProxy: 12mm ReidBar Coupler Galvanised (2)
In: Level 1
Type - Material: S. G. Iron
Pset_BuildingElementProxyCommon - Reference: 12mm ReidBar Coupler Galvanised
Name
M_ReidBar Couplers AUS:12mm ReidBar Coupler Galvanised:209373
M_ReidBar Couplers NZ:12mm ReidBar Coupler Galvanised:242017

# IfcBuildingElementProxy: 12mm ReidBar Grout Sleeve (2)
In: Level 1
Type - Material: S.G. Iron Grade 600/3
Pset_BuildingElementProxyCommon - Reference: 12mm ReidBar Grout Sleeve
Name
M_ReidBar Grout Sleeve NZ:12mm ReidBar Grout Sleeve:210416
M_ReidBar Grout Sleeve AUS:12mm ReidBar Grout Sleeve:239183

# IfcBuildingElementProxy: 12mm ReidBar Steel Coupler, M_ReidBar Coupler Galvanised:12mm ReidBar Steel Coupler:218591
In: Level 1
Type - Material: Steel
Pset_BuildingElementProxyCommon - Reference: 12mm ReidBar Steel Coupler

# IfcBuildingElementProxy: 12mm ReidBar Steel Coupler Galvanised, M_ReidBar Coupler Galvanised:12mm ReidBar Steel Coupler Galvanised:218582
In: Level 1
Type - Material: Steel Galvanised
Pset_BuildingElementProxyCommon - Reference: 12mm ReidBar Steel Coupler Galvanised

# IfcBuildingElementProxy: 12mm ReidBar Steel Threaded Insert, M_ReidBar Threaded Insert NZ:12mm ReidBar Steel Threaded Insert:211533
In: Level 1
Type - Material: Steel
Pset_BuildingElementProxyCommon - Reference: 12mm ReidBar Steel Threaded Insert

# IfcBuildingElementProxy: 12mm ReidBar Threaded Insert (2)
In: Level 1
Type - Material: S. G. Iron
Pset_BuildingElementProxyCommon - Reference: 12mm ReidBar Threaded Insert
Name
M_ReidBar Threaded Insert NZ:12mm ReidBar Threaded Insert:211538
M_ReidBar Threaded Insert AUS:12mm ReidBar Threaded Insert:234892

# IfcBuildingElementProxy: 12mm ReidBrace End, M_ReidBrace End:12mm ReidBrace End:212515
In: Level 1
Type - Material: S. G. Iron Galvanised
Pset_BuildingElementProxyCommon - Reference: 12mm ReidBrace End

# IfcBuildingElementProxy: 16mm ReidBar Coupler (2)
In: Level 1
Type - Material: S. G. Iron
Pset_BuildingElementProxyCommon - Reference: 16mm ReidBar Coupler
Name
M_ReidBar Couplers AUS:16mm ReidBar Coupler:209378
M_ReidBar Couplers NZ:16mm ReidBar Coupler:242018

# IfcBuildingElementProxy: 16mm ReidBar Coupler Galvanised (2)
In: Level 1
Type - Material: S. G. Iron
Pset_BuildingElementProxyCommon - Reference: 16mm ReidBar Coupler Galvanised
Name
M_ReidBar Couplers AUS:16mm ReidBar Coupler Galvanised:209383
M_ReidBar Couplers NZ:16mm ReidBar Coupler Galvanised:242019

# IfcBuildingElementProxy: 16mm ReidBar Grout Sleeve (2)
In: Level 1
Type - Material: S.G. Iron Grade 600/3
Pset_BuildingElementProxyCommon - Reference: 16mm ReidBar Grout Sleeve
Name
M_ReidBar Grout Sleeve NZ:16mm ReidBar Grout Sleeve:210433
M_ReidBar Grout Sleeve AUS:16mm ReidBar Grout Sleeve:239184

# IfcBuildingElementProxy: 16mm ReidBar Steel Coupler Galvanised, M_ReidBar Coupler Galvanised:16mm ReidBar Steel Coupler Galvanised:208470
In: Level 1
Type - Material: Steel Galvanised
Pset_BuildingElementProxyCommon - Reference: 16mm ReidBar Steel Coupler Galvanised

# IfcBuildingElementProxy: 16mm ReidBar Steel Threaded Insert, M_ReidBar Threaded Insert NZ:16mm ReidBar Steel Threaded Insert:211554
In: Level 1
Type - Material: Steel
Pset_BuildingElementProxyCommon - Reference: 16mm ReidBar Steel Threaded Insert

# IfcBuildingElementProxy: 16mm ReidBar Threaded Insert (2)
In: Level 1
Type - Material: S. G. Iron
Pset_BuildingElementProxyCommon - Reference: 16mm ReidBar Threaded Insert
Name
M_ReidBar Threaded Insert NZ:16mm ReidBar Threaded Insert:211559
M_ReidBar Threaded Insert AUS:16mm ReidBar Threaded Insert:234893

# IfcBuildingElementProxy: 16mm ReidBrace End, M_ReidBrace End:16mm ReidBrace End:212531
In: Level 1
Type - Material: S. G. Iron Galvanised
Pset_BuildingElementProxyCommon - Reference: 16mm ReidBrace End

# IfcBuildingElementProxy: 20mm ReidBar Coupler (2)
In: Level 1
Type - Material: S. G. Iron
Pset_BuildingElementProxyCommon - Reference: 20mm ReidBar Coupler
Name
M_ReidBar Couplers AUS:20mm ReidBar Coupler:209399
M_ReidBar Couplers NZ:20mm ReidBar Coupler:242020

# IfcBuildingElementProxy: 20mm ReidBar Coupler Galvanised (2)
In: Level 1
Type - Material: S. G. Iron
Pset_BuildingElementProxyCommon - Reference: 20mm ReidBar Coupler Galvanised
Name
M_ReidBar Couplers AUS:20mm ReidBar Coupler Galvanised:241977
M_ReidBar Couplers NZ:20mm ReidBar Coupler Galvanised:242026

# IfcBuildingElementProxy: 20mm ReidBar Grout Sleeve (2)
In: Level 1
Type - Material: S.G. Iron Grade 600/3
Pset_BuildingElementProxyCommon - Reference: 20mm ReidBar Grout Sleeve
Name
M_ReidBar Grout Sleeve NZ:20mm ReidBar Grout Sleeve:210438
M_ReidBar Grout Sleeve AUS:20mm ReidBar Grout Sleeve:239185

# IfcBuildingElementProxy: 20mm ReidBar Steel Coupler Galvanised, M_ReidBar Coupler Galvanised:20mm ReidBar Steel Coupler Galvanised:208428
In: Level 1
Type - Material: Steel Galvanised
Pset_BuildingElementProxyCommon - Reference: 20mm ReidBar Steel Coupler Galvanised

# IfcBuildingElementProxy: 20mm ReidBar Steel Threaded Insert, M_ReidBar Threaded Insert NZ:20mm ReidBar Steel Threaded Insert:211564
In: Level 1
Type - Material: Steel
Pset_BuildingElementProxyCommon - Reference: 20mm ReidBar Steel Threaded Insert

# IfcBuildingElementProxy: 20mm ReidBar Threaded Insert (2)
In: Level 1
Type - Material: S. G. Iron
Pset_BuildingElementProxyCommon - Reference: 20mm ReidBar Threaded Insert
Name
M_ReidBar Threaded Insert NZ:20mm ReidBar Threaded Insert:211569
M_ReidBar Threaded Insert AUS:20mm ReidBar Threaded Insert:234894

# IfcBuildingElementProxy: 20mm ReidBrace, M_ReidBrace:20mm ReidBrace:214544
In: Level 1
Type - Material: S. G. Iron Galvanised
Pset_BuildingElementProxyCommon - Reference: 20mm ReidBrace

# IfcBuildingElementProxy: 20mm ReidBrace End, M_ReidBrace End:20mm ReidBrace End:212557
In: Level 1
Type - Material: S. G. Iron Galvanised
Pset_BuildingElementProxyCommon - Reference: 20mm ReidBrace End

# IfcBuildingElementProxy: 25mm ReidBar Coupler (2)
In: Level 1
Type - Material: S. G. Iron
Pset_BuildingElementProxyCommon - Reference: 25mm ReidBar Coupler
Name
M_ReidBar Couplers AUS:25mm ReidBar Coupler:241978
M_ReidBar Couplers NZ:25mm ReidBar Coupler:242027

# IfcBuildingElementProxy: 25mm ReidBar Coupler Galvanised (2)
In: Level 1
Type - Material: S. G. Iron
Pset_BuildingElementProxyCommon - Reference: 25mm ReidBar Coupler Galvanised
Name
M_ReidBar Couplers AUS:25mm ReidBar Coupler Galvanised:241979
M_ReidBar Couplers NZ:25mm ReidBar Coupler Galvanised:242028

# IfcBuildingElementProxy: 25mm ReidBar Grout Sleeve (2)
In: Level 1
Type - Material: S.G. Iron Grade 600/3
Pset_BuildingElementProxyCommon - Reference: 25mm ReidBar Grout Sleeve
Name
M_ReidBar Grout Sleeve NZ:25mm ReidBar Grout Sleeve:210443
M_ReidBar Grout Sleeve AUS:25mm ReidBar Grout Sleeve:239186

# IfcBuildingElementProxy: 25mm ReidBar Steel Coupler Galvanised, M_ReidBar Coupler Galvanised:25mm ReidBar Steel Coupler Galvanised:208460
In: Level 1
Type - Material: Steel Galvanised
Pset_BuildingElementProxyCommon - Reference: 25mm ReidBar Steel Coupler Galvanised

# IfcBuildingElementProxy: 25mm ReidBar Threaded Insert, M_ReidBar Threaded Insert AUS:25mm ReidBar Threaded Insert:234895
In: Level 1
Type - Material: S. G. Iron
Pset_BuildingElementProxyCommon - Reference: 25mm ReidBar Threaded Insert

# IfcBuildingElementProxy: 25mm ReidBrace, M_ReidBrace:25mm ReidBrace:228724
In: Level 1
Type - Material: S. G. Iron Galvanised
Pset_BuildingElementProxyCommon - Reference: 25mm ReidBrace

# IfcBuildingElementProxy: 25mm ReidBrace End, M_ReidBrace End:25mm ReidBrace End:212562
In: Level 1
Type - Material: S. G. Iron Galvanised
Pset_BuildingElementProxyCommon - Reference: 25mm ReidBrace End

# IfcBuildingElementProxy: 32mm ReidBar Coupler (2)
In: Level 1
Type - Material: S. G. Iron
Pset_BuildingElementProxyCommon - Reference: 32mm ReidBar Coupler
Name
M_ReidBar Couplers AUS:32mm ReidBar Coupler:241980
M_ReidBar Couplers NZ:32mm ReidBar Coupler:242029

# IfcBuildingElementProxy: 32mm ReidBar Coupler Galvanised (2)
In: Level 1
Type - Material: S. G. Iron
Pset_BuildingElementProxyCommon - Reference: 32mm ReidBar Coupler Galvanised
Name
M_ReidBar Couplers AUS:32mm ReidBar Coupler Galvanised:241981
M_ReidBar Couplers NZ:32mm ReidBar Coupler Galvanised:242030

# IfcBuildingElementProxy: 32mm ReidBar Grout Sleeve (2)
In: Level 1
Type - Material: S.G. Iron Grade 600/3
Pset_BuildingElementProxyCommon - Reference: 32mm ReidBar Grout Sleeve
Name
M_ReidBar Grout Sleeve NZ:32mm ReidBar Grout Sleeve:210448
M_ReidBar Grout Sleeve AUS:32mm ReidBar Grout Sleeve:239187

# IfcBuildingElementProxy: 32mm ReidBar Steel Coupler Galvanised, M_ReidBar Coupler Galvanised:32mm ReidBar Steel Coupler Galvanised:208465
In: Level 1
Type - Material: Steel Galvanised
Pset_BuildingElementProxyCommon - Reference: 32mm ReidBar Steel Coupler Galvanised

# IfcBuildingElementProxy: 32mm ReidBar Threaded Insert, M_ReidBar Threaded Insert AUS:32mm ReidBar Threaded Insert:234896
In: Level 1
Type - Material: S. G. Iron
Pset_BuildingElementProxyCommon - Reference: 32mm ReidBar Threaded Insert

# IfcBuildingElementProxy: 32mm ReidBrace, M_ReidBrace:32mm ReidBrace:245271
In: Level 1
Type - Material: S. G. Iron Galvanised
Pset_BuildingElementProxyCommon - Reference: 32mm ReidBrace

# IfcBuildingElementProxy: 32mm ReidBrace End, M_ReidBrace End:32mm ReidBrace End:212567
In: Level 1
Type - Material: S. G. Iron Galvanised
Pset_BuildingElementProxyCommon - Reference: 32mm ReidBrace End

# IfcBuildingElementProxy: FE10045, M_Swiftlift Foot Anchor:FE10045:216372
In: Level 1
Type - Material: Zinc Plated
Pset_BuildingElementProxyCommon - Reference: FE10045

# IfcBuildingElementProxy: FE10045SS, M_Swiftlift Foot Anchor:FE10045SS:216385
In: Level 1
Type - Material: Stainless Steel
Pset_BuildingElementProxyCommon - Reference: FE10045SS

# IfcBuildingElementProxy: FE20095, M_Swiftlift Foot Anchor:FE20095:216399
In: Level 1
Type - Material: Zinc Plated
Pset_BuildingElementProxyCommon - Reference: FE20095

# IfcBuildingElementProxy: FE20095GH, M_Swiftlift Foot Anchor:FE20095GH:216402
In: Level 1
Type - Material: Galvanised Steel
Pset_BuildingElementProxyCommon - Reference: FE20095GH

# IfcBuildingElementProxy: FE20095SS, M_Swiftlift Foot Anchor:FE20095SS:216405
In: Level 1
Type - Material: Stainless Steel
Pset_BuildingElementProxyCommon - Reference: FE20095SS

# IfcBuildingElementProxy: FS16070, M_Stiletto Ferrule:FS16070:215421
In: Level 1
Type - Material: Zinc Plated
Pset_BuildingElementProxyCommon - Reference: FS16070

# IfcBuildingElementProxy: FS16070GH, M_Stiletto Ferrule:FS16070GH:215427
In: Level 1
Type - Material: Galvanised Steel
Pset_BuildingElementProxyCommon - Reference: FS16070GH

# IfcBuildingElementProxy: FS16095, M_Stiletto Ferrule:FS16095:215435
In: Level 1
Type - Material: Zinc Plated
Pset_BuildingElementProxyCommon - Reference: FS16095

# IfcBuildingElementProxy: FS16095GH, M_Stiletto Ferrule:FS16095GH:215449
In: Level 1
Type - Material: Galvanised Steel
Pset_BuildingElementProxyCommon - Reference: FS16095GH

# IfcBuildingElementProxy: FS20070, M_Stiletto Ferrule:FS20070:215452
In: Level 1
Type - Material: Zinc Plated
Pset_BuildingElementProxyCommon - Reference: FS20070

# IfcBuildingElementProxy: FS20070GH, M_Stiletto Ferrule:FS20070GH:215455
In: Level 1
Type - Material: Galvanised Steel
Pset_BuildingElementProxyCommon - Reference: FS20070GH

# IfcBuildingElementProxy: FS20095, M_Stiletto Ferrule:FS20095:215458
In: Level 1
Type - Material: Zinc Plated
Pset_BuildingElementProxyCommon - Reference: FS20095

# IfcBuildingElementProxy: FS20095GH, M_Stiletto Ferrule:FS20095GH:215461
In: Level 1
Type - Material: Galvanised Steel
Pset_BuildingElementProxyCommon - Reference: FS20095GH

# IfcBuildingElementProxy: OrbiPlate M16, M_OrbiPlate:OrbiPlate M16:207568
In: Level 1
Type - Material: Galvanised Steel
Pset_BuildingElementProxyCommon - Reference: OrbiPlate M16

# IfcBuildingElementProxy: OrbiPlate M20, M_OrbiPlate:OrbiPlate M20:207546
In: Level 1
Type - Material: Galvanised Steel
Pset_BuildingElementProxyCommon - Reference: OrbiPlate M20

# IfcBuildingElementProxy: SJS, M_Edge Lift:SJS:205935
In: Level 1
Pset_BuildingElementProxyCommon - Reference: SJS

# IfcBuildingElementProxy: SJU, M_Edge Lift:SJU:205912
In: Level 1
Type - Material: Galvanised Steel
Pset_BuildingElementProxyCommon - Reference: SJU
