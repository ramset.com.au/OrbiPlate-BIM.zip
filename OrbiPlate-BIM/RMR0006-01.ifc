Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: RMR0006
Time: 2021-01-15T16:59:57
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190327_2315(x64) - Exporter 20.0.0.377 - Alternate UI 20.0.0.377
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jan 15 16:59:57 2021 * Host: DESKTOP-6FN9L0T * Database: C:\Users\MPC\AppData\Local\Temp\e4e5e9ea-8279-4290-bcb7-4b920ff23ace\4a93a91f-9ba7-4967-86cd-e7a387e326ad\ifc * Database version: 5507 * Database creation date: Fri Jan 15 16:59:47 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jan 15 16:59:47 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jan 15 16:59:48 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, RMR0006
LongName: 3D Widgets

# IfcSite, Default
RefLatitude: -35, -18, -23, -549194; RefLongitude: 149, 7, 35, 603027; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Ground Floor
LongName: Ground Floor; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Ground Floor
Pset_ProductRequirements - Name: Ground Floor; Category: Levels

# IfcSpace, 1
In: Ground Floor
LongName: ggggggggggggggggggggggggggggggggggg; InteriorOrExteriorSpace: INTERNAL; Group: Rentable
Pset_AirSideSystemInformation - Name: ggggggggggggggggggggggggggggggggggg
Pset_ProductRequirements - Name: ggggggggggggggggggggggggggggggggggg; Category: Areas
Pset_SpaceCommon - Reference: ggggggggggggggggggggggggggggggggggg 1; Category: Areas

# IfcBuildingElementProxy: 12mm ReidBar Half Nut Galvanised, M_ReidBar Half Nut Galvanised:12mm ReidBar Half Nut Galvanised:280239
In: Ground Floor
Type - Material: S.G. Iron Galvanised
Type - Pset_BuildingElementProxyCommon - Reference: 12mm ReidBar Half Nut Galvanised
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 12mm ReidBar Half Nut Galvanised
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 12mm ReidBar Nut (2)
In: Ground Floor
Type - Material: S.G. Iron
Type - Pset_BuildingElementProxyCommon - Reference: 12mm ReidBar Nut
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 12mm ReidBar Nut
Pset_BuildingElementProxyCommon - sets with these values: 2
Name
M_ReidBar Nut NZ:12mm ReidBar Nut:281500
M_ReidBar Nut AUS:12mm ReidBar Nut:305932

# IfcBuildingElementProxy: 12mm ReidBar Nut Galvanised (2)
In: Ground Floor
Type - Material: S.G. Iron
Type - Pset_BuildingElementProxyCommon - Reference: 12mm ReidBar Nut Galvanised
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 12mm ReidBar Nut Galvanised
Pset_BuildingElementProxyCommon - sets with these values: 2
Name
M_ReidBar Nut NZ:12mm ReidBar Nut Galvanised:303497
M_ReidBar Nut AUS:12mm ReidBar Nut Galvanised:305942

# IfcBuildingElementProxy: 16mm ReidBar Flange Nut, M_ReidBar Flange Nut:16mm ReidBar Flange Nut:278997
In: Ground Floor
Type - Material: S.G. Iron
Type - Pset_BuildingElementProxyCommon - Reference: 16mm ReidBar Flange Nut
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 16mm ReidBar Flange Nut
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 16mm ReidBar Half Nut Galvanised, M_ReidBar Half Nut Galvanised:16mm ReidBar Half Nut Galvanised:280409
In: Ground Floor
Type - Material: S.G. Iron Galvanised
Type - Pset_BuildingElementProxyCommon - Reference: 16mm ReidBar Half Nut Galvanised
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 16mm ReidBar Half Nut Galvanised
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 16mm ReidBar Nut (2)
In: Ground Floor
Type - Material: S.G. Iron
Type - Pset_BuildingElementProxyCommon - Reference: 16mm ReidBar Nut
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 16mm ReidBar Nut
Pset_BuildingElementProxyCommon - sets with these values: 2
Name
M_ReidBar Nut NZ:16mm ReidBar Nut:281633
M_ReidBar Nut AUS:16mm ReidBar Nut:305934

# IfcBuildingElementProxy: 16mm ReidBar Nut Galvanised (2)
In: Ground Floor
Type - Material: S.G. Iron
Type - Pset_BuildingElementProxyCommon - Reference: 16mm ReidBar Nut Galvanised
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 16mm ReidBar Nut Galvanised
Pset_BuildingElementProxyCommon - sets with these values: 2
Name
M_ReidBar Nut NZ:16mm ReidBar Nut Galvanised:303499
M_ReidBar Nut AUS:16mm ReidBar Nut Galvanised:305944

# IfcBuildingElementProxy: 16mm ReidBar Steel Flange Nut, M_ReidBar Steel Flange Nut:16mm ReidBar Steel Flange Nut:302350
In: Ground Floor
Type - Material: Steel
Type - Pset_BuildingElementProxyCommon - Reference: 16mm ReidBar Steel Flange Nut
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 16mm ReidBar Steel Flange Nut
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 16mm ReidBar Steel Flange Nut Galvanised, M_ReidBar Steel Flange Nut:16mm ReidBar Steel Flange Nut Galvanised:302391
In: Ground Floor
Type - Material: Steel Galvanised
Type - Pset_BuildingElementProxyCommon - Reference: 16mm ReidBar Steel Flange Nut Galvanised
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 16mm ReidBar Steel Flange Nut Galvanised
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 20mm ReidBar Flange Nut, M_ReidBar Flange Nut:20mm ReidBar Flange Nut:279221
In: Ground Floor
Type - Material: S.G. Iron
Type - Pset_BuildingElementProxyCommon - Reference: 20mm ReidBar Flange Nut
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 20mm ReidBar Flange Nut
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 20mm ReidBar Half Nut Galvanised, M_ReidBar Half Nut Galvanised:20mm ReidBar Half Nut Galvanised:280425
In: Ground Floor
Type - Material: S.G. Iron Galvanised
Type - Pset_BuildingElementProxyCommon - Reference: 20mm ReidBar Half Nut Galvanised
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 20mm ReidBar Half Nut Galvanised
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 20mm ReidBar Nut (2)
In: Ground Floor
Type - Material: S.G. Iron
Type - Pset_BuildingElementProxyCommon - Reference: 20mm ReidBar Nut
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 20mm ReidBar Nut
Pset_BuildingElementProxyCommon - sets with these values: 2
Name
M_ReidBar Nut NZ:20mm ReidBar Nut:281650
M_ReidBar Nut AUS:20mm ReidBar Nut:305935

# IfcBuildingElementProxy: 20mm ReidBar Nut Galvanised (2)
In: Ground Floor
Type - Material: S.G. Iron
Type - Pset_BuildingElementProxyCommon - Reference: 20mm ReidBar Nut Galvanised
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 20mm ReidBar Nut Galvanised
Pset_BuildingElementProxyCommon - sets with these values: 2
Name
M_ReidBar Nut NZ:20mm ReidBar Nut Galvanised:303500
M_ReidBar Nut AUS:20mm ReidBar Nut Galvanised:305945

# IfcBuildingElementProxy: 20mm ReidBar Steel Flange Nut, M_ReidBar Steel Flange Nut:20mm ReidBar Steel Flange Nut:302353
In: Ground Floor
Type - Material: Steel
Type - Pset_BuildingElementProxyCommon - Reference: 20mm ReidBar Steel Flange Nut
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 20mm ReidBar Steel Flange Nut
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 20mm ReidBar Steel Flange Nut Galvanised, M_ReidBar Steel Flange Nut:20mm ReidBar Steel Flange Nut Galvanised:302393
In: Ground Floor
Type - Material: Steel Galvanised
Type - Pset_BuildingElementProxyCommon - Reference: 20mm ReidBar Steel Flange Nut Galvanised
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 20mm ReidBar Steel Flange Nut Galvanised
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 25mm ReidBar Flange Nut, M_ReidBar Flange Nut:25mm ReidBar Flange Nut:279235
In: Ground Floor
Type - Material: S.G. Iron
Type - Pset_BuildingElementProxyCommon - Reference: 25mm ReidBar Flange Nut
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 25mm ReidBar Flange Nut
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 25mm ReidBar Half Nut Galvanised, M_ReidBar Half Nut Galvanised:25mm ReidBar Half Nut Galvanised:280428
In: Ground Floor
Type - Material: S.G. Iron Galvanised
Type - Pset_BuildingElementProxyCommon - Reference: 25mm ReidBar Half Nut Galvanised
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 25mm ReidBar Half Nut Galvanised
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 25mm ReidBar Nut (2)
In: Ground Floor
Type - Material: S.G. Iron
Type - Pset_BuildingElementProxyCommon - Reference: 25mm ReidBar Nut
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 25mm ReidBar Nut
Pset_BuildingElementProxyCommon - sets with these values: 2
Name
M_ReidBar Nut NZ:25mm ReidBar Nut:281653
M_ReidBar Nut AUS:25mm ReidBar Nut:305936

# IfcBuildingElementProxy: 25mm ReidBar Nut Galvanised (2)
In: Ground Floor
Type - Material: S.G. Iron
Type - Pset_BuildingElementProxyCommon - Reference: 25mm ReidBar Nut Galvanised
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 25mm ReidBar Nut Galvanised
Pset_BuildingElementProxyCommon - sets with these values: 2
Name
M_ReidBar Nut NZ:25mm ReidBar Nut Galvanised:303501
M_ReidBar Nut AUS:25mm ReidBar Nut Galvanised:305946

# IfcBuildingElementProxy: 25mm ReidBar Steel Flange Nut, M_ReidBar Steel Flange Nut:25mm ReidBar Steel Flange Nut:302354
In: Ground Floor
Type - Material: Steel
Type - Pset_BuildingElementProxyCommon - Reference: 25mm ReidBar Steel Flange Nut
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 25mm ReidBar Steel Flange Nut
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 25mm ReidBar Steel Flange Nut Galvanised, M_ReidBar Steel Flange Nut:25mm ReidBar Steel Flange Nut Galvanised:302394
In: Ground Floor
Type - Material: Steel Galvanised
Type - Pset_BuildingElementProxyCommon - Reference: 25mm ReidBar Steel Flange Nut Galvanised
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 25mm ReidBar Steel Flange Nut Galvanised
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 32mm ReidBar Flange Nut, M_ReidBar Flange Nut:32mm ReidBar Flange Nut:279238
In: Ground Floor
Type - Material: S.G. Iron
Type - Pset_BuildingElementProxyCommon - Reference: 32mm ReidBar Flange Nut
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 32mm ReidBar Flange Nut
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 32mm ReidBar Half Nut Galvanised, M_ReidBar Half Nut Galvanised:32mm ReidBar Half Nut Galvanised:280431
In: Ground Floor
Type - Material: S.G. Iron Galvanised
Type - Pset_BuildingElementProxyCommon - Reference: 32mm ReidBar Half Nut Galvanised
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 32mm ReidBar Half Nut Galvanised
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 32mm ReidBar Nut (2)
In: Ground Floor
Type - Material: S.G. Iron
Type - Pset_BuildingElementProxyCommon - Reference: 32mm ReidBar Nut
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 32mm ReidBar Nut
Pset_BuildingElementProxyCommon - sets with these values: 2
Name
M_ReidBar Nut NZ:32mm ReidBar Nut:281656
M_ReidBar Nut AUS:32mm ReidBar Nut:305937

# IfcBuildingElementProxy: 32mm ReidBar Nut Galvanised (2)
In: Ground Floor
Type - Material: S.G. Iron
Type - Pset_BuildingElementProxyCommon - Reference: 32mm ReidBar Nut Galvanised
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 32mm ReidBar Nut Galvanised
Pset_BuildingElementProxyCommon - sets with these values: 2
Name
M_ReidBar Nut NZ:32mm ReidBar Nut Galvanised:303502
M_ReidBar Nut AUS:32mm ReidBar Nut Galvanised:305947

# IfcBuildingElementProxy: 32mm ReidBar Steel Flange Nut, M_ReidBar Steel Flange Nut:32mm ReidBar Steel Flange Nut:302355
In: Ground Floor
Type - Material: Steel
Type - Pset_BuildingElementProxyCommon - Reference: 32mm ReidBar Steel Flange Nut
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 32mm ReidBar Steel Flange Nut
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 32mm ReidBar Steel Flange Nut Galvanised, M_ReidBar Steel Flange Nut:32mm ReidBar Steel Flange Nut Galvanised:302395
In: Ground Floor
Type - Material: Steel Galvanised
Type - Pset_BuildingElementProxyCommon - Reference: 32mm ReidBar Steel Flange Nut Galvanised
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 32mm ReidBar Steel Flange Nut Galvanised
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: 3DX85RXTI, M_3DX85RF Threaded Insert:3DX85RXTI:287490
In: Ground Floor
Type - Material: Brass
Type - Pset_BuildingElementProxyCommon - Reference: 3DX85RXTI
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: 3DX85RXTI
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: Brass Insert - SJU, M_SJUVF Brass Insert:Brass Insert - SJU:298353
In: Ground Floor
Type - Material: Brass
Type - Pset_BuildingElementProxyCommon - Reference: Brass Insert - SJU
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: Brass Insert - SJU
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: FHD20140, M_Double Round Ferrule:FHD20140:289721
In: Ground Floor
Type - Material: Zinc Plated
Type - Pset_BuildingElementProxyCommon - Reference: FHD20140
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: FHD20140
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: M10, M_ChemSet Maxima Anchor Stud:M10:277871
In: Ground Floor
Type - Material: Galvanised Steel
Type - Pset_BuildingElementProxyCommon - Reference: M10
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: M10
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: M12, M_ChemSet Maxima Anchor Stud:M12:277884
In: Ground Floor
Type - Material: Galvanised Steel
Type - Pset_BuildingElementProxyCommon - Reference: M12
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: M12
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: M16, M_ChemSet Maxima Anchor Stud:M16:277887
In: Ground Floor
Type - Material: Galvanised Steel
Type - Pset_BuildingElementProxyCommon - Reference: M16
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: M16
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: M20, M_ChemSet Maxima Anchor Stud:M20:277890
In: Ground Floor
Type - Material: Galvanised Steel
Type - Pset_BuildingElementProxyCommon - Reference: M20
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: M20
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: M24, M_ChemSet Maxima Anchor Stud:M24:277893
In: Ground Floor
Type - Material: Galvanised Steel
Type - Pset_BuildingElementProxyCommon - Reference: M24
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: M24
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: M8, M_ChemSet Maxima Anchor Stud:M8:277589
In: Ground Floor
Type - Material: Galvanised Steel
Type - Pset_BuildingElementProxyCommon - Reference: M8
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: M8
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: NP12RBG, M_ReidBar Nail Plate:NP12RBG:292781
In: Ground Floor
Type - Pset_BuildingElementProxyCommon - Reference: NP12RBG
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: NP12RBG
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: NP16RBG, M_ReidBar Nail Plate:NP16RBG:292969
In: Ground Floor
Type - Pset_BuildingElementProxyCommon - Reference: NP16RBG
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: NP16RBG
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: NP32RB, M_ReidBar Nail Plate:NP32RB:292985
In: Ground Floor
Type - Pset_BuildingElementProxyCommon - Reference: NP32RB
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: NP32RB
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: RBRACE 12, M_RBrace Pin:RBRACE 12:290759
In: Ground Floor
Type - Material: Galvanised Alloy Steel
Type - Pset_BuildingElementProxyCommon - Reference: RBRACE 12
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: RBRACE 12
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: RBRACE 16, M_RBrace Pin:RBRACE 16:292889
In: Ground Floor
Type - Material: Galvanised Alloy Steel
Type - Pset_BuildingElementProxyCommon - Reference: RBRACE 16
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: RBRACE 16
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: RBRACE 20, M_RBrace Pin:RBRACE 20:292917
In: Ground Floor
Type - Material: Galvanised Alloy Steel
Type - Pset_BuildingElementProxyCommon - Reference: RBRACE 20
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: RBRACE 20
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: RBRACE 25, M_RBrace Pin:RBRACE 25:292920
In: Ground Floor
Type - Material: Galvanised Alloy Steel
Type - Pset_BuildingElementProxyCommon - Reference: RBRACE 25
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: RBRACE 25
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: RBRACE 32, M_RBrace Pin:RBRACE 32:292923
In: Ground Floor
Type - Material: Galvanised Alloy Steel
Type - Pset_BuildingElementProxyCommon - Reference: RBRACE 32
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: RBRACE 32
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: RBRACE25 Link Plate, M_ReidBrace Link Plate:RBRACE25 Link Plate:297031
In: Ground Floor
Type - Material: Galvanised Steel
Type - Pset_BuildingElementProxyCommon - Reference: RBRACE25 Link Plate
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: RBRACE25 Link Plate
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: RBRACE32 Link Plate, M_ReidBrace Link Plate:RBRACE32 Link Plate:297150
In: Ground Floor
Type - Material: Galvanised Steel
Type - Pset_BuildingElementProxyCommon - Reference: RBRACE32 Link Plate
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: RBRACE32 Link Plate
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: RBX085LN1205200, M_ReidBar Rebox:RBX085LN1205200:295709
In: Ground Floor
Type - Pset_BuildingElementProxyCommon - Reference: RBX085LN1205200
Type - Pset_ConcreteElementQuantityGeneral - RebarDiameter: 12 mm
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: RBX085LN1205200
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: RBX085LN1207200, M_ReidBar Rebox:RBX085LN1207200:296066
In: Ground Floor
Type - Pset_BuildingElementProxyCommon - Reference: RBX085LN1207200
Type - Pset_ConcreteElementQuantityGeneral - RebarDiameter: 12 mm
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: RBX085LN1207200
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: RBX120UN1205200, M_ReidBar Rebox:RBX120UN1205200:296081
In: Ground Floor
Type - Pset_BuildingElementProxyCommon - Reference: RBX120UN1205200
Type - Pset_ConcreteElementQuantityGeneral - RebarDiameter: 12 mm
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: RBX120UN1205200
Pset_BuildingElementProxyCommon - sets with these values: 2

# IfcBuildingElementProxy: RBX120UN1207200, M_ReidBar Rebox:RBX120UN1207200:296084
In: Ground Floor
Type - Pset_BuildingElementProxyCommon - Reference: RBX120UN1207200
Type - Pset_ConcreteElementQuantityGeneral - RebarDiameter: 12 mm
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: RBX120UN1207200
Pset_BuildingElementProxyCommon - sets with these values: 2
